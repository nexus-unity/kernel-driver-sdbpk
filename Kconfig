## Kconfig
```kconfig
config SDBPK
tristate "SDBPK Driver"
depends on SPI && GPIOLIB
default m
help
sdbpk driver
```
